Commit message: readme 动态视图

File: so100_with_marker.urdf (robot description, URDF)
Before this commit: robot so_arm100, 8 links, 7 joints
Joints:
- joint marker_joint: parent base_link -> base
